# Keil uVision project Project.uvprojx, settings and files
target GD32E501 (6190000::V6.19::ARMCLANG)
  device: GD32E501RE GigaDevice
  pack: GigaDevice.GD32E501_DFP.1.0.2
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Project_app
  AfterMake: D:\D\app\kevil5\ARM\ARMCLANG\bin\fromelf.exe --bin --output .\Output\Project_app.bin .\Output\Project_app.axf
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E501,EXT_CTRL_MCU,CHIP_TYPE=1
  c include: ..\..\mcu;..\..\mcu\GDE501_fireware;..\..\mcu\GDE501_fireware\Firmware\CMSIS;..\..\mcu\GDE501_fireware\Firmware\CMSIS\GD\GD32E501\Include;..\..\mcu\GDE501_fireware\Firmware\GD32E501_standard_peripheral\Include;..\..\mcu\GDE501_fireware\Utilities;..\..\mcu\i2c_opt_ie;..\..\mcu\adc_sample_comm;..\..\mcu\dac_comm;..\..\mcu\i2c_comm;..\..\include;..\..\driver\dsp_fsl;..\..\driver\GN7153;..\..\driver\GN7161;..\..\driver\UX3326;..\..\other;..\..\other\sgm2508_EA;..\..\other\sgm41282_APD;..\..\other\sgm41295_EA_SOA;..\..\other\sgm41296_TEC;..\..\update;..\..\thermistor_rth;..\..\tec_control;..\..\ddm_process;..\..\ddm_process\ddm_1g_config;..\..\ddm_process\ddm_10g_config;..\..\ddm_process\ddm_50g_config;..\..\thd_dsp_download_release_V0_0
  library: MicroLIB
  memory RVCT4: ROM 0x8007800 size 0x15000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group mcu_Application
    ../../mcu/GDE501_fireware/: systick.c gd32e501_it.c
    ../../mcu/: com_usart_comm.c mcu_config_public.c mcu_system_comm.c timer_comm.c mcu_global_vars_param.c
    ../../mcu/adc_sample_comm/: adc_sample_driver.c adc_sample_interface.c adc_sample_comm.c
    ../../mcu/dac_comm/: dac_driver.c dac_comm.c
    ../../mcu/i2c_comm/: i2c_comm.c i2c_driver.c
    ../../mcu/i2c_opt_ie/: i2c_opt_ie.c
  group mcu_CMSIS
    ../../mcu/GDE501_fireware/Firmware/CMSIS/GD/GD32E501/Source/: system_gd32e501.c
  group mcu_Peripherals
    ../../mcu/GDE501_fireware/Firmware/GD32E501_standard_peripheral/Source/: gd32e501_adc.c gd32e501_cla.c gd32e501_cmp.c gd32e501_crc.c gd32e501_dac.c gd32e501_dbg.c gd32e501_dma.c gd32e501_exti.c gd32e501_fmc.c gd32e501_fwdgt.c gd32e501_gpio.c gd32e501_i2c.c gd32e501_mdio.c gd32e501_misc.c gd32e501_pmu.c gd32e501_rcu.c gd32e501_rtc.c gd32e501_spi.c gd32e501_syscfg.c gd32e501_timer.c gd32e501_usart.c gd32e501_wwdgt.c
  group mcu_Startup
    ../../mcu/GDE501_fireware/Firmware/CMSIS/GD/GD32E501/Source/ARM/: startup_gd32e501.s
  group mcu_Utilities
    ../../mcu/GDE501_fireware/Utilities/: gd32e501_eval.c
  group Doc
    ../: readme.txt
  group driver
    ../../driver/GN7161/: gn7161.c
    ../../driver/GN7153/: gn7153.c
    ../../driver/UX3326/: ux3326.c
    ../../driver/dsp_fsl/: dsp_fsl.c dsp_fsl_i2c_interface.c
  group other
    ../../other/sgm41295_EA_SOA/: sgm41295_ea_soa.c sgm41295_ea_soa.h
    ../../other/sgm2508_EA/: sgm2508_ea.c sgm2508_ea.h
    ../../other/sgm41282_APD/: sgm41282c_apd.c sgm41282c_apd.h
    ../../other/sgm41296_TEC/: sgm41296_tec.c sgm41296_tec.h
    ../../other/: trigger_interrupt_mode.c trigger_interrupt_mode.h
  group tec_control
    ../../tec_control/: tec_comm.c tec_i2c_interface.c tec_driver.c
  group source
    ../: main.c
  group update
    ../../update/: update_comm.c update_i2c_interface.c
  group include
    ../../include/: user_config.h
  group ddm_process
    ../../ddm_process/: ddm_i2c_interface.c ddm_i2c_interface.h ddm_sff_i2c_interface.c ddm_sff_i2c_interface.h sff_8472.c sff_8472.h
    ../../ddm_process/ddm_1g_config/: ddm_1g_config_interface.c
    ../../ddm_process/ddm_10g_config/: ddm_10g_config_interface.c
    ../../ddm_process/ddm_50g_config/: ddm_50g_config_interface.c
  group thermistor_rth
    ../../thermistor_rth/: thermistor_rth.c thermistor_rth.h
  group thd_dsp_download
    ../../thd_dsp_download_release_V0_0/: do_cmd_struct.c ip_op.c reg_op.c dsp_hpll_init.c
software components: CMSIS:CORE 5.2.0
